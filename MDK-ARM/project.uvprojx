# Keil uVision project project.uvprojx, settings and files
target stm32g030f6 (6150000::V6.15::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: stm32g030f6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx,xMODBUS_RTU_ENABLE
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\User\APP;..\User\BSP\inc;..\User\BSP;..\User\FONT;..\User\SEGGER\RTT\RTT;..\User\ModbusRTU\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Bsp
    ../User/BSP/src/: bsp_timer.c bsp_beep.c bsp_led.c bsp_uart_fifo.c bsp_iwdg.c bsp_user_lib.c bsp_tim_pwm.c bsp_icm42605.c bsp_cpu_spi1.c
    ../User/BSP/: bsp.c
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_gpio.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group SEGGER/RTT
    ../User/SEGGER/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group ModbusRtu
    ../User/ModbusRTU/src/: modbus_host.c modbus_slave.c
    ../User/ModbusRTU/inc/: modbus_cfg.h modbus_host.h modbus_rtu.h modbus_slave.h
software components: CMSIS:CORE 5.4.0
