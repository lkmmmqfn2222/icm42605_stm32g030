<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32g030f6.ewp</path>
  </project>
  <batchBuild />
</workspace>
